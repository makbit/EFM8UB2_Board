# Keil uVision project PwmBlink.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8UB20F64G-QFP48 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: PwmBlink +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../inc
  group Source Group 1
    ./: main.c
